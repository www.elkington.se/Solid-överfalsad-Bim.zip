Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: OVERLAP-VO-200X100.IFC
Time: 2019-03-28T12:49:13
Author: com2it
Organization: Hewlett-Packard Company
Written by: SwIFC
Made in: SolidWorks 2015

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: FRAME A-VO-200-SLOT
In: Default Storey
PSet_Mass_Property - Mass Measure: 44.6233; Area Measure: 8.34687 m2; Volume Measure: 0.0178399 m3
